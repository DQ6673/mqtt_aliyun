# Keil uVision project master.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\SYSTEM\usart;..\SYSTEM\sys;..\SYSTEM\delay;..\USER;..\CORE;..\HARDWARE\TIM;..\HARDWARE\EXTI;..\HARDWARE\RELAY;..\HARDWARE\BUZZER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\DS18B20;..\HARDWARE\24Cxx;..\HARDWARE\IIC;..\HARDWARE\ESP8266;..\HARDWARE\MCP3421
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/LCD/: lcd1602.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DS18B20/: ds18b20z.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24Cxx/: 24cxx.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/MCP3421/: mcp3421.c
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c syscfg.c main.c
